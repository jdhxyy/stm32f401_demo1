# Keil uVision project work.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: work +hex
  AfterMake: fromelf --bin !L --output D004V004.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\lib\STM32F4xx_StdPeriph_Driver\inc;.\lib\CMSIS\Include;.\lib\CMSIS\ST\STM32F4xx\Include;.;.\clib\tztime;.\clib\lagan-clang;.\clib\tzcomponent-clang;.\clib\tzmalloc;.\clib\tzstm32f4;.\clib\tztype-clang;.\clib\tzat-clang;.\clib\tzfifo;.\clib\tzlist;.\clib\crc16-clang;.\clib\espat-clang;.\clib\async-clang;.\clib\pt;.\clib\utz-clang;.\clib\dcom-clang;.\clib\knock-clang;.\clib\tzaccess-clang;.\clib\tzbox;.\clib\tziot-clang;.\include;.\drivers\include;.\framework\include;.\application
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./lib/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StartUp
    ./lib/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Lib
    ./lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group tztime
    ./clib/tztime/: tztime.c
  group tzmalloc
    ./clib/tzmalloc/: bget.c tzmalloc.c
  group tzstm32f4
    ./clib/tzstm32f4/: tzstm32f4io.c tzstm32f4iwdg.c tzstm32f4uart1.c tzstm32f4uart3.c tzstm32f4uart4.c tzstm32f4uart6.c tzstm32f4uartcom.c
  group tzat
    ./clib/tzat-clang/: tzat.c
  group tzfifo
    ./clib/tzfifo/: tzfifo.c
  group tzlist
    ./clib/tzlist/: tzlist.c
  group crc16
    ./clib/crc16-clang/: crc16.c
  group espat
    ./clib/espat-clang/: espat.c
  group async
    ./clib/async-clang/: async.c
  group lagan
    ./clib/lagan-clang/: lagan.c
  group utz
    ./clib/utz-clang/: utzcommon.c utzehp.c utzflp.c utznlv1.c
  group dcom
    ./clib/dcom-clang/: dcom.c dcomblockrx.c dcomblocktx.c dcomcallback.c dcomcommon.c dcomlog.c dcomparam.c dcomrx.c dcomrxcon.c dcomtx.c dcomwaitlist.c
  group tzbox
    ./clib/tzbox/: tzbox.c
  group knock
    ./clib/knock-clang/: knock.c
  group tzaccess
    ./clib/tzaccess-clang/: tzaccess.c tzaccessapply.c tzaccessconfig.c tzaccessconn.c tzaccessparsecmp.c tzaccessstandardlayer.c
  group tziot
    ./clib/tziot-clang/: tziot.c tziotconfig.c tziotdcom.c tziotpipe.c tziotstandardlayer.c
  group drivers
    ./drivers/source/: drvclock.c stm32f4xx_it.c
  group framework
    ./framework/source/: clock.c
  group application
    ./applications/: main.c
